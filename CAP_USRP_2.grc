options:
  parameters:
    generate_options: qt_gui
    id: CAP_USRP_v1
    output_language: python
    title: CAP_USRP_v1
  states: {}

blocks:
- name: Data
  id: variable
  parameters:
    value: numpy.random.randint(M,size=dat_len)
  states: {}
- name: Data_0
  id: variable
  parameters:
    value: '[3,3,2,2,0,0,1,1,0,0,3,3,1,2,1,1,0,1,3,3,0,2,2,2,1,3,3,2,3,2,3,0,0,0,1,3,0,2,1,3,1,3,3,3,2,2,2,1,0,2,1,2,0,1,0,0,1,0,1,1,1,1,2,1,2,2,2,3,3,3,2,0,0,3,2,0,2,0,2,3,2,1,2,3,1,1,2,1,1,2,2,0,3,1,1,1,3,2,0,1,2,3,3,1,1,3,0,1,0,2,3,1,0,2,2,2,2,2,1,3,3,1,0,3,3,3,1,3,0,1,2,0,1,0,2,1,1,3,3,1,1,1,2,1,1,1,2,0,0,3,2,0,3,3,0,1,2,1,3,0,2,2,0,2,2,1,0,3,2,2,0,3,1,2,1,3,0,3,3,3,0,2,3,1,0,2,2,0,2,1,2,2,0,3,2,0,1,3,2,3,1,1,2,3,0,1,1,2,3,2,2,2,1,0,0,0,1,3,1,3,1,2,1,1,1,1,1,3,2,2,2,2,1,2,3,0,1,0,2,2]'
  states: {}
- name: M
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,1,1,1
    label: Modulation Order
    num_opts: '5'
    option0: '4'
    option1: '16'
    option2: '64'
    option3: '256'
    option4: '1024'
    orient: Qt.QHBoxLayout
    type: int
    value: '4'
    widget: radio_buttons
  states: {}
- name: dat_len
  id: variable
  parameters:
    value: fram_len//filt_len
  states: {}
- name: filt_len
  id: variable
  parameters:
    value: span*sps+1
  states: {}
- name: fram_len
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: frame_len
  id: variable
  parameters:
    value: (dat_len*filt_len)
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Frequency
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '0.5'
    value: '0.25'
  states: {}
- name: inph
  id: variable
  parameters:
    value: numpy.multiply(rrrc,numpy.cos(numpy.array(range(filt_len))*2*math.pi*freq))
  states: {}
- name: quad
  id: variable
  parameters:
    value: numpy.multiply(rrrc,numpy.sin(numpy.array(range(filt_len))*2*math.pi*freq))
  states: {}
- name: rrrc
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.1'
    gain: numpy.sqrt(sps*2)
    ntaps: filt_len
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: span
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /Users/keremenhos/Desktop/NEU/VLC v2/GNURadio/data_test.dat
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /Users/keremenhos/Desktop/NEU/VLC v2/GNURadio/data_test2.dat
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /Users/keremenhos/Desktop/NEU/VLC v2/GNURadio/data_test2.dat
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: filt_len
    offset: filt_len-2
    type: complex
  states: {}
- name: blocks_keep_m_in_n_1
  id: blocks_keep_m_in_n
  parameters:
    m: frame_len
    n: fram_len
    offset: '0'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(frame_len-1)
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: int
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: packet_len
    packet_len: '510'
    type: float
  states: {}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: packet_len
    maxoutbuf: '8192'
    packet_len: frame_len
    type: float
  states: {}
- name: blocks_stream_to_tagged_stream_2
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: pck
    packet_len: frame_len
    type: float
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: float
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: float
  states: {}
- name: blocks_vector_insert_x_0
  id: blocks_vector_insert_x
  parameters:
    offset: '0'
    period: filt_len
    type: float
    vector: '[0]*(filt_len-1)'
  states: {state: disabled}
- name: blocks_vector_insert_x_0_0
  id: blocks_vector_insert_x
  parameters:
    offset: '0'
    period: filt_len
    type: float
    vector: '[0]*(filt_len-1)'
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[0,0,0,0,0,0,0,0,1,0,0,0,1,0,0,0,1,1,0,0,1,0,0,0,1,1,1,0,1,0,1,0,1,1,0,1,1,0,0,0,1,1,1,0,0,0,1,0,0,1,0,1,0,1,0,0,0,1,1,0,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,0,1,1,0,1,1,1,0,0,1,0,1,0,0,1,0,0,0,0,0,1,0,0,1,1,0,0,1,1,1,0,1,0,0,0,1,1,1,1,1,0,1,1,1,1,0,0,0,0,0,1,1,1,1,1,1,1,1,1,0,0,0,0,1,1,1,1,0,1,1,1,0,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,1,1,1,1,0,1,0,0,0,0,1,1,1,0,0,1,1,0,0,0,0,1,0,0,1,0,0,0,1,0,1,0,1,1,1,0,1,0,1,1,1,1,0,0,1,0,0,1,0,1,1,1,0,0,1,1,1,0,0,0,0,0,0,1,1,1,0,1,1,1,0,1,0,0,1,1,1,1,0,1,0,1,0,0,1,0,1,0,0,0,0,0,0,1,0,1,0,1,0,1,0,1,1,1,1,1,0,1,0,1,1,0,1,0,0,0,0,0,1,1,0,1,1,1,0,1,1,0,1,1,0,1,0,1,1,0,0,0,0,0,1,0,1,1,1,0,1,1,1,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,0,0,1,1,0,1,0,1,1,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,1,1,1,1,1,0,1,0,0,1,0,1,1,0,0,0,1,0,1,0,0,1,1,0,0,0,1,1,0,0,0,0,0,0,0,1,1,0,0,1,1,0,0,1,0,1,0,1,1,0,0,1,0,0,1,1,1,1,1,1,0,1,1,0,1,0,0,1,0,0,1,0,0,1,1,0,1,1,1,1,1,1,0,0,1,0,1,1,0,1,0,1,0,0,0,0,1,0,1,0,0,0,1,0,0,1,1,1,0,1,1,0,0,1,0,1,1,1,1,0,1,1,0,0,0,0,1,1,0,1,0,1,0,1,0,0,1,1,1,0,0,1,0,0,0,0,1,1,0,0,0,1,0,0,0,0]'
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: int
    vector: Data
  states: {state: disabled}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: range(frame_len)
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fram_len
    type: float
  states: {state: disabled}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '509'
    sps: '1'
    symbols: '[0,0,0,0,0,0,0,0,1,0,0,0,1,0,0,0,1,1,0,0,1,0,0,0,1,1,1,0,1,0,1,0,1,1,0,1,1,0,0,0,1,1,1,0,0,0,1,0,0,1,0,1,0,1,0,0,0,1,1,0,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,0,1,1,0,1,1,1,0,0,1,0,1,0,0,1,0,0,0,0,0,1,0,0,1,1,0,0,1,1,1,0,1,0,0,0,1,1,1,1,1,0,1,1,1,1,0,0,0,0,0,1,1,1,1,1,1,1,1,1,0,0,0,0,1,1,1,1,0,1,1,1,0,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,1,1,1,1,0,1,0,0,0,0,1,1,1,0,0,1,1,0,0,0,0,1,0,0,1,0,0,0,1,0,1,0,1,1,1,0,1,0,1,1,1,1,0,0,1,0,0,1,0,1,1,1,0,0,1,1,1,0,0,0,0,0,0,1,1,1,0,1,1,1,0,1,0,0,1,1,1,1,0,1,0,1,0,0,1,0,1,0,0,0,0,0,0,1,0,1,0,1,0,1,0,1,1,1,1,1,0,1,0,1,1,0,1,0,0,0,0,0,1,1,0,1,1,1,0,1,1,0,1,1,0,1,0,1,1,0,0,0,0,0,1,0,1,1,1,0,1,1,1,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,0,0,1,1,0,1,0,1,1,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,1,1,1,1,1,0,1,0,0,1,0,1,1,0,0,0,1,0,1,0,0,1,1,0,0,0,1,1,0,0,0,0,0,0,0,1,1,0,0,1,1,0,0,1,0,1,0,1,1,0,0,1,0,0,1,1,1,1,1,1,0,1,1,0,1,0,0,1,0,0,1,0,0,1,1,0,1,1,1,1,1,1,0,0,1,0,1,1,0,1,0,1,0,0,0,0,1,0,1,0,0,0,1,0,0,1,1,1,0,1,1,0,0,1,0,1,1,1,1,0,1,1,0,0,0,0,1,1,0,1,0,1,0,1,0,0,1,1,1,0,0,1,0,0,0,0,1,1,0,0,0,1,0,0,0,0]'
    threshold: '0.05'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    M: M
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, M=4):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='QAM Modulator',   # will show up in GRC
                  in_sig=[np.int32],
                  out_sig=[np.complex64]
              )
              self.M = M
              self.tM = M
              n = np.arange(0,self.M)
              a = np.asarray([x^(x>>1) for x in n])
              D = np.sqrt(self.M).astype(int)
              a = np.reshape(a,(D,D))
              a[1::2, :] = a[1::2, ::-1]
              nGray=np.reshape(a,(self.M))
              x = nGray//D
              y = nGray%D
              Ay=2*y+1-D
              Ax=2*x+1-D
              self.cons = Ax+1j*Ay
              self.cons = self.cons/np.max(np.absolute((np.real(self.cons))))

          def work(self, input_items, output_items):
              if self.M != self.tM:
                  n = np.arange(0,self.M)
                  a = np.asarray([x^(x>>1) for x in n])
                  D = np.sqrt(self.M).astype(int)
                  a = np.reshape(a,(D,D))
                  a[1::2, :] = a[1::2, ::-1]
                  nGray=np.reshape(a,(self.M))
                  x = nGray//D
                  y = nGray%D
                  Ay=2*y+1-D
                  Ax=2*x+1-D
                  self.cons = Ax+1j*Ay
                  self.cons = self.cons/np.max(np.absolute((np.real(self.cons))))
                  self.tM = self.M
              for x in range(len(input_items[0])):
                  output_items[0][x] = self.cons[input_items[0][x]]
              
              
              return len(output_items[0])
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import time
      import random
      import numpy as np

      from gnuradio import gr
      from gnuradio import gr_unittest
      from gnuradio import digital
      from gnuradio import blocks
      from gnuradio import grc
      import pmt
      import inspect

      def get_top_variable(variable_name="", default=None):
          try:
              top = inspect.currentframe().f_back.f_back.f_locals
              if top.__contains__(variable_name):
                  return top[variable_name]
              top = inspect.currentframe().f_back.f_back.f_back.f_back.f_back.f_locals
              if top.__contains__("self") and \
                      (isinstance(top['self'], grc.gui.canvas.flowgraph.FlowGraph)) and \
                      (hasattr(top['self'], 'blocks')):
                  block_names = [block.name for block in top['self'].blocks]
                  block_index = block_names.index(variable_name)
                  result = top['self'].blocks[block_index].params['value'].value
                  return result
          except Exception as e:
              print("[Block Debug]: Threw an exception", e)
          except:
              print("[Block Debug]: Threw an unknown exception.")
          return default

      class blk(gr.sync_block):
          def __init__(self, frame_length=1):
              fram_len = get_top_variable("fram_len", default=10)
              gr.sync_block.__init__(
                  self,
                  name="Preamble Demux",
                  in_sig=[np.float32],
      #            out_sig=[(np.float32,fram_len if isinstance(fram_len, int) else int(fram_len))]
                  out_sig=[np.float32]
              )
              self.aa = 0
              self.buf = []
              self.off = 0
              self.det = 0
              self.flg2 = 0
              self.a = 0
              self.b = 0
              self.fram_len = fram_len
              self.frame_length = frame_length
              
          
          def work(self, input_items, output_items):
              if self.det == 0:
                  tags = self.get_tags_in_window(0, 0, len(input_items[0]))
                  
                  for tag in tags:
                      offset = tag.offset
                      key = pmt.to_python(tag.key) # convert from PMT to python string
                      if key == 'corr_est':
                          self.off = offset
                          self.det = 1
                          self.flg2 = 0
                          self.buf.extend(input_items[0][(self.off-self.aa)+1:])
                          
      #                    break
                          
              if len(self.buf)<self.frame_length and self.det == 1 and self.flg2 == 1:
                  self.buf.extend(input_items[0])
              
              if len(self.buf)>=self.frame_length and self.det == 1 and self.flg2 == 1 and len(output_items[0])>=self.frame_length:
                  output_items[0][:self.frame_length] = self.buf[:self.frame_length]
                  self.buf = []
                  self.det = 0
                  
                  
              self.b = self.b + 1
                  
              self.flg2 = 1
              self.aa = self.aa + len(input_items[0])
              print(self.det)
              return len(output_items[0][0])
    frame_length: frame_len
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    M: M
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import time
      import random
      import numpy as np

      from gnuradio import gr
      from gnuradio import gr_unittest
      from gnuradio import digital
      from gnuradio import blocks
      from gnuradio import grc
      import pmt
      import inspect


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, data_length=1.0, M=4, tag='', bin_data=[]):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='QAM Demodulator',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.int32, np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.data_length = data_length
              self.buf = []
              self.tag = tag
              self.aa = 0
              self.det = 0
              self.flg2 = 0
              self.bin_data = bin_data
              self.c = 0
              self.ber = 0
              self.cc = 0
              self.t = 0
              self.bert = 0
              self.M=M
              self.sM = int(np.sqrt(self.M))

              
          def get_minimum_distances(self, sample):
               if (sample.imag >= 0 and sample.real >= 0):
                   return 3 # 1+1j
               elif (sample.imag >= 0 and sample.real < 0):
                   return 1 # -1+1j
               elif (sample.imag < 0 and sample.real < 0):
                   return 0 # -1-1j
               elif (sample.imag < 0 and sample.real >= 0):
                   return 2 # 1-1j
                       
          def dec2bin(self, x, n=0):
              return format(x, 'b').zfill(n)

          def work(self, input_items, output_items):
              if self.det == 0:
                  tags = self.get_tags_in_window(0, 0, len(input_items[0]))
                  for tagg in tags:
                      offset = tagg.offset
                      key = pmt.to_python(tagg.key) # convert from PMT to python string
                      if key == self.tag:
                          self.off = offset
                          self.det = 1
                          self.flg2 = 0
                          self.buf.extend(input_items[0][(self.off-self.aa)+1:])
      #                    print(self.tag)
                          break
                          
              if len(self.buf)<self.data_length and self.det == 1 and self.flg2 == 1:
                  self.buf.extend(input_items[0])
                  
              if self.cc == 0:
                  self.t = time.time()
                  self.cc = 1
              
              if len(self.buf)>=self.data_length and self.det == 1 and self.flg2 == 1 and len(output_items[0])>=self.data_length:
                  for i in range(0, self.data_length):
                      d = self.buf[i]
                      output_items[0][i] = self.get_minimum_distances(d)
      #                output_items[1][i] = self.bert
                      if self.dec2bin(output_items[0][i],int(np.sqrt(self.M))) != self.dec2bin(self.bin_data[i],int(np.sqrt(self.M))):
                          self.ber = self.ber + np.count_nonzero(np.array(list(map(int,(self.dec2bin(output_items[0][i],int(np.sqrt(self.M)))))))-np.array(list(map(int,(self.dec2bin(self.bin_data[i],int(np.sqrt(self.M))))))))
                  output_items[1][:] = self.ber
                  self.ber = 0
                  self.c = self.c + 1
                  
      #            if self.c > 10//(len(self.bin_data)*int(np.sqrt(self.M))):
      #                self.bert = self.ber/(self.c*len(self.bin_data)*int(np.sqrt(self.M)))
      ##                output_items[1][:self.data_length] = self.bert
      #                self.c = 0
      #                self.ber = 0
      #                self.cc = 0
                  self.buf = []
                  self.det = 0
      #        output_items[1][:self.data_length] = self.bert
              self.flg2 = 1
              
              self.aa = self.aa + len(input_items[0])

              return len(output_items[0])
    bin_data: Data
    data_length: dat_len
    tag: '''pck'''
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: quad
    type: fff
  states: {state: disabled}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: numpy.flip(quad)
    type: fff
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: inph
    type: fff
  states: {state: disabled}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: numpy.flip(inph)
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math,cmath,numpy
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: (0,0,2,1)
    size: '1024'
    type: complex
    update_time: '0.1'
  states: {state: disabled}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    gui_hint: (1,1,1,1)
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    avg: 1000//(dat_len*int(numpy.sqrt(M)))
    color1: ("black", "white")
    factor1: float(1)/(dat_len*int(numpy.sqrt(M)))
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 3,0,1,1
    label1: BER
    max: '0.0000001'
    min: '0'
    name: BER
    type: float
    update_time: '0.01'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: corr_est
    type: float
    update_time: '0.01'
    ymax: '70000'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,1,1,1
    nconnections: '2'
    size: '128'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: pck
    type: complex
    update_time: '0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_2
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (0,1,1,1)
    size: '256'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: pck
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '4096'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: corr_est
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    size: '8192'
    srate: samp_rate
    tr_tag: pck
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: '0'
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: '0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_stream_to_tagged_stream_1, '0']
- [blocks_complex_to_float_0, '0', blocks_vector_insert_x_0, '0']
- [blocks_complex_to_float_0, '1', blocks_vector_insert_x_0_0, '0']
- [blocks_complex_to_float_1, '0', epy_block_1, '0']
- [blocks_complex_to_float_1, '0', qtgui_time_sink_x_3, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_file_sink_0, '0']
- [blocks_float_to_complex_1, '0', blocks_keep_m_in_n_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_null_sink_0, '0']
- [blocks_keep_m_in_n_0, '0', epy_block_2, '0']
- [blocks_keep_m_in_n_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_keep_m_in_n_0, '0', qtgui_time_sink_x_1_2, '0']
- [blocks_keep_m_in_n_1, '0', blocks_tag_gate_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_stream_to_tagged_stream_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_stream_to_tagged_stream_2, '0', fir_filter_xxx_0_0, '0']
- [blocks_stream_to_tagged_stream_2, '0', fir_filter_xxx_1_0, '0']
- [blocks_stream_to_tagged_stream_2, '0', qtgui_freq_sink_x_0, '0']
- [blocks_tag_gate_0, '0', blocks_stream_to_tagged_stream_2, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_float_to_complex_0, '0']
- [blocks_vector_insert_x_0, '0', fir_filter_xxx_1, '0']
- [blocks_vector_insert_x_0_0, '0', fir_filter_xxx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_vector_source_x_0_0, '0', epy_block_0, '0']
- [blocks_vector_source_x_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_keep_m_in_n_1, '0']
- [digital_corr_est_cc_0, '0', blocks_complex_to_float_1, '0']
- [digital_corr_est_cc_0, '0', qtgui_time_sink_x_2, '0']
- [digital_corr_est_cc_0, '1', blocks_complex_to_mag_squared_0, '0']
- [epy_block_0, '0', blocks_complex_to_float_0, '0']
- [epy_block_0, '0', blocks_delay_0, '0']
- [epy_block_0, '0', blocks_file_sink_0_0, '0']
- [epy_block_0, '0', qtgui_const_sink_x_1, '0']
- [epy_block_1, '0', blocks_keep_m_in_n_1, '0']
- [epy_block_2, '0', blocks_null_sink_1, '0']
- [epy_block_2, '1', qtgui_number_sink_1, '0']
- [fir_filter_xxx_0, '0', blocks_add_xx_0, '1']
- [fir_filter_xxx_0_0, '0', blocks_float_to_complex_1, '1']
- [fir_filter_xxx_1, '0', blocks_add_xx_0, '0']
- [fir_filter_xxx_1_0, '0', blocks_float_to_complex_1, '0']
- [uhd_usrp_source_0, '0', digital_corr_est_cc_0, '0']

metadata:
  file_format: 1
